require giflib_${PV}.bb

S = "${WORKDIR}/giflib-${PV}"

PACKAGES = ""

inherit autotools native
