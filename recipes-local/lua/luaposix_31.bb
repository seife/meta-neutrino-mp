include luaposix.inc
# this might change as the year of release is in there
LIC_FILES_CHKSUM = "file://COPYING;md5=0de24acdcec9cb21ff095356966cbef2"

PR = "r1"

SRC_URI[md5sum] = "a25ff76d54bbbebf7a1f3b20c9806ee3"
SRC_URI[sha256sum] = "c5ed2f6c16b9f31d3ca0db05f9b660db69c966baab244878480ab6658abbbe24"
